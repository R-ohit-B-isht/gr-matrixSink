options:
  parameters:
    generate_options: qt_gui
    id: ms2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1'
    type: float
    vlen: '100'
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '100'
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1'
    type: float
    vlen: '100'
  states: {}
- name: matrixSink_matrix_sink_0
  id: matrixSink_matrix_sink
  parameters:
    name: '"Matrix Sink"'
    num_cols: '10'
    vlen: '100'
    x_axis_label: '"x-Axis"'
    x_end: '1'
    x_start: '0'
    y_axis_label: '"y-Axis"'
    y_end: '1'
    y_start: '0'
    z_axis_label: '"z-Axis"'
    z_max: '1'
    z_min: '0'
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_stream_to_vector_0, '0', matrixSink_matrix_sink_0, '0']
- [blocks_stream_to_vector_1, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
